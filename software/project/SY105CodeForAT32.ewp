# IAR project SY105CodeForAT32.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT32F403ACGU7_v2 ArteryTek -AT32F403ACGU7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; __FPU_PRESENT=1
  ICCARM.CCDiagSuppress: Pa082,Pe068,Pe111,Pa118
  ICCARM.CCIncludePath2: ..\at32periph\inc; ..\app\inc; ..\cmsis\DSP_Lib; ..\cmsis; ..\user; $PROJ_DIR$; ..\utils\inc; ..\protocol\inc; ..\protocol\tuya_wifi\inc; ..\protocol\tuya_zigbee\inc; ..\freertos; ..\freertos\include; ..\freertos\portable; ..\app\gpio; ..\user; ..\app\usart; ..\app\lcd; ..\app\delay; ..\app\bm8563; ..\app\timer; ..\gui; ..\gui\lvgl; ..\gui\lv_examples; ..\gui\lvgl_driver; ..\app\spi
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\freertos; ..\freertos\include; ..\freertos\portable
  OBJCOPY.OOCOutputFile: SY105CodeForAT32.bin
  ILINK.IlinkOutputFile: SY105CodeForAT32.out
  ILINK.IlinkIcfFile: SY105CodeForAT32.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../app/bm8563/: bm8563.c
    ../app/delay/: delay.c
    ../app/gpio/: gpio.c
    ../app/lcd/: lcd.c lcd_init.c
    ../app/spi/: spi.c
    ../app/timer/: timer.c
    ../app/usart/: usart.c
  group at32periph
    ../at32periph/src/: at32f4xx_acc.c at32f4xx_adc.c at32f4xx_bkp.c at32f4xx_can.c at32f4xx_comp.c at32f4xx_crc.c at32f4xx_dac.c at32f4xx_dbgmcu.c at32f4xx_dma.c at32f4xx_ertc.c at32f4xx_eth.c at32f4xx_exti.c at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_i2c.c at32f4xx_iwdg.c at32f4xx_pwr.c at32f4xx_rcc.c at32f4xx_rtc.c at32f4xx_sdio.c at32f4xx_spi.c at32f4xx_syscfg.c at32f4xx_tim.c at32f4xx_usart.c at32f4xx_wwdg.c at32f4xx_xmc.c misc.c
  group freertos
    ../freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../freertos/include/: FreeRTOSConfig.h
    ../freertos/portable/: heap_4.c port.c portasm.s
  group gui
    ../gui/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_task.c lv_templ.c lv_txt.c lv_utils.c
    ../gui/lvgl/src/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
    ../gui/lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../gui/lvgl/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
    ../gui/lvgl/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_unscii_8.c
    ../gui/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../gui/lvgl_driver/: lv_port_disp.c
    ../gui/lvgl/src/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
  group gui_app
    ../gui/lv_examples/lv_apps/demo/: demo.c img_bubble_pattern.c
    ../gui/lv_examples/lv_tests/lv_test_theme/: lv_test_theme_1.c lv_test_theme_2.c
  group user
    ../user/: at32f4xx_it.c main.c
    ../cmsis/: startup_at32f403acgu7.s system_at32f4xx.c
  group utils
    ../utils/src/: my_assert.c my_check.c
